require ti-xdais.inc

PV = "6_26_01_03"

LIC_FILES_CHKSUM = "file://xdais_6_26_01_03_ReleaseNotes.html;md5=c31705b933047f4e3bbb52b6f34b0567"

SRC_URI[xdaistarball.md5sum] = "9b2bea3408254e737ec0d819a031adf6"
SRC_URI[xdaistarball.sha256sum] = "d7bcbd8bcfe6fdfc5f402e4b125ced6c806dc30bc5296e98d5d43b0b5a237a0d"


